V1 SUB 1 sin 5 40
D1 1 2 1e-12
R1 2 SUB 1e3
C1 2 SUB 10e-6
D2 2 3 1e-12
R2 3 SUB 1e3
C2 3 SUB 10e-6
R3 3 4 3e4
C3 4 SUB 10e-6
R4 3 5 4e4
C4 5 SUB 10e-6
R5 3 6 5e4
C5 6 SUB 10e-6
R6 3 7 6e4
C6 7 SUB 10e-6
R7 3 8 7e4
C7 8 SUB 10e-6
R8 3 9 8e4
C8 9 SUB 10e-6
R9 3 10 9e4
C9 10 SUB 10e-6
R10 3 11 10e4
C10 11 SUB 10e-6
