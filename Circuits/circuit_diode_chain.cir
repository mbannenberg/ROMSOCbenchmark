V1 SUB 1 sin 5 40
D1 1 2 1e-12
R1 2 SUB 1e3
C1 2 SUB 10e-6
D2 2 3 1e-12
R2 3 SUB 1e3
C2 3 SUB 10e-6
D3 3 4 1e-12
R3 4 SUB 1e3
C3 4 SUB 10e-6
D4 4 5 1e-12
R4 5 SUB 1e3
C4 5 SUB 10e-6
D5 5 6 1e-12
R5 6 SUB 1e3
C5 6 SUB 10e-6
D6 6 7 1e-12
R6 7 SUB 1e3
C6 7 SUB 10e-6
D7 7 8 1e-12
R7 8 SUB 1e3
C7 8 SUB 10e-6
D8 8 9 1e-12
R8 9 SUB 1e3
C8 9 SUB 10e-6
D9 9 10 1e-12
R9 10 SUB 1e3
C9 10 SUB 10e-6
D10 10 11 1e-12
R10 11 SUB 1e3
C10 11 SUB 10e-6
D11 11 12 1e-12
R11 12 SUB 1e3
C11 12 SUB 10e-6
D12 12 13 1e-12
R12 13 SUB 1e3
C12 13 SUB 10e-6
D13 13 14 1e-12
R13 14 SUB 1e3
C13 14 SUB 10e-6
D14 14 15 1e-12
R14 15 SUB 1e3
C14 15 SUB 10e-6
D15 15 16 1e-12
R15 16 SUB 1e3
C15 16 SUB 10e-6
D16 16 17 1e-12
R16 17 SUB 1e3
C16 17 SUB 10e-6
D17 17 18 1e-12
R17 18 SUB 1e3
C17 18 SUB 10e-6
D18 18 19 1e-12
R18 19 SUB 1e3
C18 19 SUB 10e-6
D19 19 20 1e-12
R19 20 SUB 1e3
C19 20 SUB 10e-6
D20 20 21 1e-12
R20 21 SUB 1e3
C20 21 SUB 10e-6
D21 21 22 1e-12
R21 22 SUB 1e3
C21 22 SUB 10e-6
D22 22 23 1e-12
R22 23 SUB 1e3
C22 23 SUB 10e-6
D23 23 24 1e-12
R23 24 SUB 1e3
C23 24 SUB 10e-6
D24 24 25 1e-12
R24 25 SUB 1e3
C24 25 SUB 10e-6
D25 25 26 1e-12
R25 26 SUB 1e3
C25 26 SUB 10e-6
D26 26 27 1e-12
R26 27 SUB 1e3
C26 27 SUB 10e-6
D27 27 28 1e-12
R27 28 SUB 1e3
C27 28 SUB 10e-6
D28 28 29 1e-12
R28 29 SUB 1e3
C28 29 SUB 10e-6
D29 29 30 1e-12
R29 30 SUB 1e3
C29 30 SUB 10e-6
D30 30 31 1e-12
R30 31 SUB 1e3
C30 31 SUB 10e-6
D31 31 32 1e-12
R31 32 SUB 1e3
C31 32 SUB 10e-6
D32 32 33 1e-12
R32 33 SUB 1e3
C32 33 SUB 10e-6
D33 33 34 1e-12
R33 34 SUB 1e3
C33 34 SUB 10e-6
D34 34 35 1e-12
R34 35 SUB 1e3
C34 35 SUB 10e-6
D35 35 36 1e-12
R35 36 SUB 1e3
C35 36 SUB 10e-6
D36 36 37 1e-12
R36 37 SUB 1e3
C36 37 SUB 10e-6
D37 37 38 1e-12
R37 38 SUB 1e3
C37 38 SUB 10e-6
D38 38 39 1e-12
R38 39 SUB 1e3
C38 39 SUB 10e-6
D39 39 40 1e-12
R39 40 SUB 1e3
C39 40 SUB 10e-6
D40 40 41 1e-12
R40 41 SUB 1e3
C40 41 SUB 10e-6
D41 41 42 1e-12
R41 42 SUB 1e3
C41 42 SUB 10e-6
D42 42 43 1e-12
R42 43 SUB 1e3
C42 43 SUB 10e-6
D43 43 44 1e-12
R43 44 SUB 1e3
C43 44 SUB 10e-6
D44 44 45 1e-12
R44 45 SUB 1e3
C44 45 SUB 10e-6
D45 45 46 1e-12
R45 46 SUB 1e3
C45 46 SUB 10e-6
D46 46 47 1e-12
R46 47 SUB 1e3
C46 47 SUB 10e-6
D47 47 48 1e-12
R47 48 SUB 1e3
C47 48 SUB 10e-6
D48 48 49 1e-12
R48 49 SUB 1e3
C48 49 SUB 10e-6
D49 49 50 1e-12
R49 50 SUB 1e3
C49 50 SUB 10e-6
D50 50 51 1e-12
R50 51 SUB 1e3
C50 51 SUB 10e-6
D51 51 52 1e-12
R51 52 SUB 1e3
C51 52 SUB 10e-6
D52 52 53 1e-12
R52 53 SUB 1e3
C52 53 SUB 10e-6
D53 53 54 1e-12
R53 54 SUB 1e3
C53 54 SUB 10e-6
D54 54 55 1e-12
R54 55 SUB 1e3
C54 55 SUB 10e-6
D55 55 56 1e-12
R55 56 SUB 1e3
C55 56 SUB 10e-6
D56 56 57 1e-12
R56 57 SUB 1e3
C56 57 SUB 10e-6
D57 57 58 1e-12
R57 58 SUB 1e3
C57 58 SUB 10e-6
D58 58 59 1e-12
R58 59 SUB 1e3
C58 59 SUB 10e-6
D59 59 60 1e-12
R59 60 SUB 1e3
C59 60 SUB 10e-6
D60 60 61 1e-12
R60 61 SUB 1e3
C60 61 SUB 10e-6
D61 61 62 1e-12
R61 62 SUB 1e3
C61 62 SUB 10e-6
D62 62 63 1e-12
R62 63 SUB 1e3
C62 63 SUB 10e-6
D63 63 64 1e-12
R63 64 SUB 1e3
C63 64 SUB 10e-6
D64 64 65 1e-12
R64 65 SUB 1e3
C64 65 SUB 10e-6
D65 65 66 1e-12
R65 66 SUB 1e3
C65 66 SUB 10e-6
D66 66 67 1e-12
R66 67 SUB 1e3
C66 67 SUB 10e-6
D67 67 68 1e-12
R67 68 SUB 1e3
C67 68 SUB 10e-6
D68 68 69 1e-12
R68 69 SUB 1e3
C68 69 SUB 10e-6
D69 69 70 1e-12
R69 70 SUB 1e3
C69 70 SUB 10e-6
D70 70 71 1e-12
R70 71 SUB 1e3
C70 71 SUB 10e-6
D71 71 72 1e-12
R71 72 SUB 1e3
C71 72 SUB 10e-6
D72 72 73 1e-12
R72 73 SUB 1e3
C72 73 SUB 10e-6
D73 73 74 1e-12
R73 74 SUB 1e3
C73 74 SUB 10e-6
D74 74 75 1e-12
R74 75 SUB 1e3
C74 75 SUB 10e-6
D75 75 76 1e-12
R75 76 SUB 1e3
C75 76 SUB 10e-6
D76 76 77 1e-12
R76 77 SUB 1e3
C76 77 SUB 10e-6
D77 77 78 1e-12
R77 78 SUB 1e3
C77 78 SUB 10e-6
D78 78 79 1e-12
R78 79 SUB 1e3
C78 79 SUB 10e-6
D79 79 80 1e-12
R79 80 SUB 1e3
C79 80 SUB 10e-6
D80 80 81 1e-12
R80 81 SUB 1e3
C80 81 SUB 10e-6
D81 81 82 1e-12
R81 82 SUB 1e3
C81 82 SUB 10e-6
D82 82 83 1e-12
R82 83 SUB 1e3
C82 83 SUB 10e-6
D83 83 84 1e-12
R83 84 SUB 1e3
C83 84 SUB 10e-6
D84 84 85 1e-12
R84 85 SUB 1e3
C84 85 SUB 10e-6
D85 85 86 1e-12
R85 86 SUB 1e3
C85 86 SUB 10e-6
D86 86 87 1e-12
R86 87 SUB 1e3
C86 87 SUB 10e-6
D87 87 88 1e-12
R87 88 SUB 1e3
C87 88 SUB 10e-6
D88 88 89 1e-12
R88 89 SUB 1e3
C88 89 SUB 10e-6
D89 89 90 1e-12
R89 90 SUB 1e3
C89 90 SUB 10e-6
D90 90 91 1e-12
R90 91 SUB 1e3
C90 91 SUB 10e-6
D91 91 92 1e-12
R91 92 SUB 1e3
C91 92 SUB 10e-6
D92 92 93 1e-12
R92 93 SUB 1e3
C92 93 SUB 10e-6
D93 93 94 1e-12
R93 94 SUB 1e3
C93 94 SUB 10e-6
D94 94 95 1e-12
R94 95 SUB 1e3
C94 95 SUB 10e-6
D95 95 96 1e-12
R95 96 SUB 1e3
C95 96 SUB 10e-6
D96 96 97 1e-12
R96 97 SUB 1e3
C96 97 SUB 10e-6
D97 97 98 1e-12
R97 98 SUB 1e3
C97 98 SUB 10e-6
D98 98 99 1e-12
R98 99 SUB 1e3
C98 99 SUB 10e-6
D99 99 100 1e-12
R99 100 SUB 1e3
C99 100 SUB 10e-6
D100 100 101 1e-12
R100 101 SUB 1e3
C100 101 SUB 10e-6
