V1 SUB 1 sin 5 40
D1 1 2 1e-14
R1 2 SUB 1e3
C1 2 SUB 10e-6
D2 2 3 1e-14
R2 3 SUB 1e3
C2 3 SUB 10e-6
D3 3 4 1e-14
R3 4 SUB 1e3
C3 4 SUB 10e-6
D4 4 5 1e-14
R4 5 SUB 1e3
C4 5 SUB 10e-6
D5 5 6 1e-14
R5 6 SUB 1e3
C5 6 SUB 10e-6
D6 6 7 1e-14
R6 7 SUB 1e3
C6 7 SUB 10e-6
D7 7 8 1e-14
R7 8 SUB 1e3
C7 8 SUB 10e-6
D8 8 9 1e-14
R8 9 SUB 1e3
C8 9 SUB 10e-6
D9 9 10 1e-14
R9 10 SUB 1e3
C9 10 SUB 10e-6
D10 10 11 1e-14
R10 11 SUB 1e3
C10 11 SUB 10e-6
D11 11 12 1e-14
R11 12 SUB 1e3
C11 12 SUB 10e-6
D12 12 13 1e-14
R12 13 SUB 1e3
C12 13 SUB 10e-6
D13 13 14 1e-14
R13 14 SUB 1e3
C13 14 SUB 10e-6
D14 14 15 1e-14
R14 15 SUB 1e3
C14 15 SUB 10e-6
D15 15 16 1e-14
R15 16 SUB 1e3
C15 16 SUB 10e-6
D16 16 17 1e-14
R16 17 SUB 1e3
C16 17 SUB 10e-6
D17 17 18 1e-14
R17 18 SUB 1e3
C17 18 SUB 10e-6
D18 18 19 1e-14
R18 19 SUB 1e3
C18 19 SUB 10e-6
D19 19 20 1e-14
R19 20 SUB 1e3
C19 20 SUB 10e-6
D20 20 21 1e-14
R20 21 SUB 1e3
C20 21 SUB 10e-6
D21 21 22 1e-14
R21 22 SUB 1e3
C21 22 SUB 10e-6
D22 22 23 1e-14
R22 23 SUB 1e3
C22 23 SUB 10e-6
D23 23 24 1e-14
R23 24 SUB 1e3
C23 24 SUB 10e-6
D24 24 25 1e-14
R24 25 SUB 1e3
C24 25 SUB 10e-6
D25 25 26 1e-14
R25 26 SUB 1e3
C25 26 SUB 10e-6
D26 26 27 1e-14
R26 27 SUB 1e3
C26 27 SUB 10e-6
D27 27 28 1e-14
R27 28 SUB 1e3
C27 28 SUB 10e-6
D28 28 29 1e-14
R28 29 SUB 1e3
C28 29 SUB 10e-6
D29 29 30 1e-14
R29 30 SUB 1e3
C29 30 SUB 10e-6
D30 30 31 1e-14
R30 31 SUB 1e3
C30 31 SUB 10e-6
