V1 SUB 1 sin 5 40
D1 1 2 1e-12
R1 2 SUB 1e3
C1 2 SUB 10e-6
D2 2 3 1e-12
R2 3 SUB 1e3
C2 3 SUB 10e-6
R3 3 4 3e4
C3 4 SUB 10e-6
R4 3 5 4e4
C4 5 SUB 10e-6
R5 3 6 5e4
C5 6 SUB 10e-6
R6 3 7 6e4
C6 7 SUB 10e-6
R7 3 8 7e4
C7 8 SUB 10e-6
R8 3 9 8e4
C8 9 SUB 10e-6
R9 3 10 9e4
C9 10 SUB 10e-6
R10 3 11 10e4
C10 11 SUB 10e-6
R11 3 12 11e4
C11 12 SUB 10e-6
R12 3 13 12e4
C12 13 SUB 10e-6
R13 3 14 13e4
C13 14 SUB 10e-6
R14 3 15 14e4
C14 15 SUB 10e-6
R15 3 16 15e4
C15 16 SUB 10e-6
R16 3 17 16e4
C16 17 SUB 10e-6
R17 3 18 17e4
C17 18 SUB 10e-6
R18 3 19 18e4
C18 19 SUB 10e-6
R19 3 20 19e4
C19 20 SUB 10e-6
R20 3 21 20e4
C20 21 SUB 10e-6
R21 3 22 21e4
C21 22 SUB 10e-6
R22 3 23 22e4
C22 23 SUB 10e-6
R23 3 24 23e4
C23 24 SUB 10e-6
R24 3 25 24e4
C24 25 SUB 10e-6
R25 3 26 25e4
C25 26 SUB 10e-6
R26 3 27 26e4
C26 27 SUB 10e-6
R27 3 28 27e4
C27 28 SUB 10e-6
R28 3 29 28e4
C28 29 SUB 10e-6
R29 3 30 29e4
C29 30 SUB 10e-6
R30 3 31 30e4
C30 31 SUB 10e-6
R31 3 32 31e4
C31 32 SUB 10e-6
R32 3 33 32e4
C32 33 SUB 10e-6
R33 3 34 33e4
C33 34 SUB 10e-6
R34 3 35 34e4
C34 35 SUB 10e-6
R35 3 36 35e4
C35 36 SUB 10e-6
R36 3 37 36e4
C36 37 SUB 10e-6
R37 3 38 37e4
C37 38 SUB 10e-6
R38 3 39 38e4
C38 39 SUB 10e-6
R39 3 40 39e4
C39 40 SUB 10e-6
R40 3 41 40e4
C40 41 SUB 10e-6
R41 3 42 41e4
C41 42 SUB 10e-6
R42 3 43 42e4
C42 43 SUB 10e-6
R43 3 44 43e4
C43 44 SUB 10e-6
R44 3 45 44e4
C44 45 SUB 10e-6
R45 3 46 45e4
C45 46 SUB 10e-6
R46 3 47 46e4
C46 47 SUB 10e-6
R47 3 48 47e4
C47 48 SUB 10e-6
R48 3 49 48e4
C48 49 SUB 10e-6
R49 3 50 49e4
C49 50 SUB 10e-6
R50 3 51 50e4
C50 51 SUB 10e-6
R51 3 52 51e4
C51 52 SUB 10e-6
R52 3 53 52e4
C52 53 SUB 10e-6
R53 3 54 53e4
C53 54 SUB 10e-6
R54 3 55 54e4
C54 55 SUB 10e-6
R55 3 56 55e4
C55 56 SUB 10e-6
R56 3 57 56e4
C56 57 SUB 10e-6
R57 3 58 57e4
C57 58 SUB 10e-6
R58 3 59 58e4
C58 59 SUB 10e-6
R59 3 60 59e4
C59 60 SUB 10e-6
R60 3 61 60e4
C60 61 SUB 10e-6
R61 3 62 61e4
C61 62 SUB 10e-6
R62 3 63 62e4
C62 63 SUB 10e-6
R63 3 64 63e4
C63 64 SUB 10e-6
R64 3 65 64e4
C64 65 SUB 10e-6
R65 3 66 65e4
C65 66 SUB 10e-6
R66 3 67 66e4
C66 67 SUB 10e-6
R67 3 68 67e4
C67 68 SUB 10e-6
R68 3 69 68e4
C68 69 SUB 10e-6
R69 3 70 69e4
C69 70 SUB 10e-6
R70 3 71 70e4
C70 71 SUB 10e-6
R71 3 72 71e4
C71 72 SUB 10e-6
R72 3 73 72e4
C72 73 SUB 10e-6
R73 3 74 73e4
C73 74 SUB 10e-6
R74 3 75 74e4
C74 75 SUB 10e-6
R75 3 76 75e4
C75 76 SUB 10e-6
R76 3 77 76e4
C76 77 SUB 10e-6
R77 3 78 77e4
C77 78 SUB 10e-6
R78 3 79 78e4
C78 79 SUB 10e-6
R79 3 80 79e4
C79 80 SUB 10e-6
R80 3 81 80e4
C80 81 SUB 10e-6
R81 3 82 81e4
C81 82 SUB 10e-6
R82 3 83 82e4
C82 83 SUB 10e-6
R83 3 84 83e4
C83 84 SUB 10e-6
R84 3 85 84e4
C84 85 SUB 10e-6
R85 3 86 85e4
C85 86 SUB 10e-6
R86 3 87 86e4
C86 87 SUB 10e-6
R87 3 88 87e4
C87 88 SUB 10e-6
R88 3 89 88e4
C88 89 SUB 10e-6
R89 3 90 89e4
C89 90 SUB 10e-6
R90 3 91 90e4
C90 91 SUB 10e-6
R91 3 92 91e4
C91 92 SUB 10e-6
R92 3 93 92e4
C92 93 SUB 10e-6
R93 3 94 93e4
C93 94 SUB 10e-6
R94 3 95 94e4
C94 95 SUB 10e-6
R95 3 96 95e4
C95 96 SUB 10e-6
R96 3 97 96e4
C96 97 SUB 10e-6
R97 3 98 97e4
C97 98 SUB 10e-6
R98 3 99 98e4
C98 99 SUB 10e-6
R99 3 100 99e4
C99 100 SUB 10e-6
R100 3 101 100e4
C100 101 SUB 10e-6
R101 3 102 101e4
C101 102 SUB 10e-6
R102 3 103 102e4
C102 103 SUB 10e-6
R103 3 104 103e4
C103 104 SUB 10e-6
R104 3 105 104e4
C104 105 SUB 10e-6
R105 3 106 105e4
C105 106 SUB 10e-6
R106 3 107 106e4
C106 107 SUB 10e-6
R107 3 108 107e4
C107 108 SUB 10e-6
R108 3 109 108e4
C108 109 SUB 10e-6
R109 3 110 109e4
C109 110 SUB 10e-6
R110 3 111 110e4
C110 111 SUB 10e-6
R111 3 112 111e4
C111 112 SUB 10e-6
R112 3 113 112e4
C112 113 SUB 10e-6
R113 3 114 113e4
C113 114 SUB 10e-6
R114 3 115 114e4
C114 115 SUB 10e-6
R115 3 116 115e4
C115 116 SUB 10e-6
R116 3 117 116e4
C116 117 SUB 10e-6
R117 3 118 117e4
C117 118 SUB 10e-6
R118 3 119 118e4
C118 119 SUB 10e-6
R119 3 120 119e4
C119 120 SUB 10e-6
R120 3 121 120e4
C120 121 SUB 10e-6
R121 3 122 121e4
C121 122 SUB 10e-6
R122 3 123 122e4
C122 123 SUB 10e-6
R123 3 124 123e4
C123 124 SUB 10e-6
R124 3 125 124e4
C124 125 SUB 10e-6
R125 3 126 125e4
C125 126 SUB 10e-6
R126 3 127 126e4
C126 127 SUB 10e-6
R127 3 128 127e4
C127 128 SUB 10e-6
R128 3 129 128e4
C128 129 SUB 10e-6
R129 3 130 129e4
C129 130 SUB 10e-6
R130 3 131 130e4
C130 131 SUB 10e-6
R131 3 132 131e4
C131 132 SUB 10e-6
R132 3 133 132e4
C132 133 SUB 10e-6
R133 3 134 133e4
C133 134 SUB 10e-6
R134 3 135 134e4
C134 135 SUB 10e-6
R135 3 136 135e4
C135 136 SUB 10e-6
R136 3 137 136e4
C136 137 SUB 10e-6
R137 3 138 137e4
C137 138 SUB 10e-6
R138 3 139 138e4
C138 139 SUB 10e-6
R139 3 140 139e4
C139 140 SUB 10e-6
R140 3 141 140e4
C140 141 SUB 10e-6
R141 3 142 141e4
C141 142 SUB 10e-6
R142 3 143 142e4
C142 143 SUB 10e-6
R143 3 144 143e4
C143 144 SUB 10e-6
R144 3 145 144e4
C144 145 SUB 10e-6
R145 3 146 145e4
C145 146 SUB 10e-6
R146 3 147 146e4
C146 147 SUB 10e-6
R147 3 148 147e4
C147 148 SUB 10e-6
R148 3 149 148e4
C148 149 SUB 10e-6
R149 3 150 149e4
C149 150 SUB 10e-6
R150 3 151 150e4
C150 151 SUB 10e-6
R151 3 152 151e4
C151 152 SUB 10e-6
R152 3 153 152e4
C152 153 SUB 10e-6
R153 3 154 153e4
C153 154 SUB 10e-6
R154 3 155 154e4
C154 155 SUB 10e-6
R155 3 156 155e4
C155 156 SUB 10e-6
R156 3 157 156e4
C156 157 SUB 10e-6
R157 3 158 157e4
C157 158 SUB 10e-6
R158 3 159 158e4
C158 159 SUB 10e-6
R159 3 160 159e4
C159 160 SUB 10e-6
R160 3 161 160e4
C160 161 SUB 10e-6
R161 3 162 161e4
C161 162 SUB 10e-6
R162 3 163 162e4
C162 163 SUB 10e-6
R163 3 164 163e4
C163 164 SUB 10e-6
R164 3 165 164e4
C164 165 SUB 10e-6
R165 3 166 165e4
C165 166 SUB 10e-6
R166 3 167 166e4
C166 167 SUB 10e-6
R167 3 168 167e4
C167 168 SUB 10e-6
R168 3 169 168e4
C168 169 SUB 10e-6
R169 3 170 169e4
C169 170 SUB 10e-6
R170 3 171 170e4
C170 171 SUB 10e-6
R171 3 172 171e4
C171 172 SUB 10e-6
R172 3 173 172e4
C172 173 SUB 10e-6
R173 3 174 173e4
C173 174 SUB 10e-6
R174 3 175 174e4
C174 175 SUB 10e-6
R175 3 176 175e4
C175 176 SUB 10e-6
R176 3 177 176e4
C176 177 SUB 10e-6
R177 3 178 177e4
C177 178 SUB 10e-6
R178 3 179 178e4
C178 179 SUB 10e-6
R179 3 180 179e4
C179 180 SUB 10e-6
R180 3 181 180e4
C180 181 SUB 10e-6
R181 3 182 181e4
C181 182 SUB 10e-6
R182 3 183 182e4
C182 183 SUB 10e-6
R183 3 184 183e4
C183 184 SUB 10e-6
R184 3 185 184e4
C184 185 SUB 10e-6
R185 3 186 185e4
C185 186 SUB 10e-6
R186 3 187 186e4
C186 187 SUB 10e-6
R187 3 188 187e4
C187 188 SUB 10e-6
R188 3 189 188e4
C188 189 SUB 10e-6
R189 3 190 189e4
C189 190 SUB 10e-6
R190 3 191 190e4
C190 191 SUB 10e-6
R191 3 192 191e4
C191 192 SUB 10e-6
R192 3 193 192e4
C192 193 SUB 10e-6
R193 3 194 193e4
C193 194 SUB 10e-6
R194 3 195 194e4
C194 195 SUB 10e-6
R195 3 196 195e4
C195 196 SUB 10e-6
R196 3 197 196e4
C196 197 SUB 10e-6
R197 3 198 197e4
C197 198 SUB 10e-6
R198 3 199 198e4
C198 199 SUB 10e-6
R199 3 200 199e4
C199 200 SUB 10e-6
R200 3 201 200e4
C200 201 SUB 10e-6
